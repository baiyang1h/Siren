# Keil uVision project Smartsock_project.uvprojx, settings and files
target nrf51822_qfaa_s130 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Smartsock +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 VIGO_CLEAN_UP BLE_DFU_APP_SUPPORT BUILD_PROD
  c misc: --c99
  c include: config;nrf51_sdk\examples\bsp;nrf51_sdk\components\toolchain;nrf51_sdk\components\ble\ble_advertising;nrf51_sdk\components\ble\common;nrf51_sdk\components\ble\device_manager;nrf51_sdk\components\drivers_nrf\common;nrf51_sdk\components\drivers_nrf\delay;nrf51_sdk\components\drivers_nrf\gpiote;nrf51_sdk\components\drivers_nrf\config;nrf51_sdk\components\drivers_nrf\hal;nrf51_sdk\components\drivers_nrf\pstorage;nrf51_sdk\components\drivers_nrf\uart;nrf51_sdk\components\libraries\button;nrf51_sdk\components\libraries\timer;nrf51_sdk\components\libraries\trace;nrf51_sdk\components\libraries\fifo;nrf51_sdk\components\libraries\uart;nrf51_sdk\components\libraries\util;nrf51_sdk\components\softdevice\common\softdevice_handler;nrf51_sdk\components\softdevice\s130\headers;nrf51_sdk\components\drivers_nrf\timer;nrf51_sdk\components\ble\ble_services\ble_dfu;nrf51_sdk\components\libraries\bootloader_dfu;nrf51_sdk\components\drivers_nrf\spi_master;nrf51_sdk\components\drivers_nrf\twi_master;nrf51_sdk\components\drivers_nrf\twi_master\deprecated;nrf51_sdk\components\ble\ble_db_discovery;nrf51_sdk\components\drivers_nrf\wdt\;extended_flash;..\SRN_DVT_Application;.\ble_service;.\lsm6dsl
  asm define: BLE_STACK_SUPPORT_REQD S130 BOARD_NRF6310 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 BLE_DFU_APP_SUPPORT
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x20000
  memory RVCT9: RAM 0x20002800 size 0x17e0
  memory RVCT10: RAM 0x20003fe0 size 0x20
  group Application
    ./: main.c
  group lsm6dsl
    ./lsm6dsl/: lsm6dsl_reg.c lsm6dsl_handle.c
  group ble_service
    ./ble_service/: ble_lbs.c
  group extended_flash
    extended_flash/: spi_flash_driver.c
    ./extended_flash/: spi_master_app.c
  group Board Support
    nrf51_sdk/examples/bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ./: Abstract.txt license.txt
  group nRF_BLE
    nrf51_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    nrf51_sdk/components/ble/ble_advertising/: ble_advertising.c
    nrf51_sdk/components/ble/device_manager/: device_manager_peripheral.c
    nrf51_sdk/components/ble/ble_services/ble_dfu/: ble_dfu.c
    nrf51_sdk/components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Drivers
    nrf51_sdk/components/drivers_nrf/delay/: nrf_delay.c
    nrf51_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    nrf51_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    nrf51_sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
    nrf51_sdk/components/drivers_nrf/pstorage/: pstorage.c
    nrf51_sdk/components/drivers_nrf/hal/: nrf_adc.c
    nrf51_sdk/components/libraries/uart/: app_uart_fifo.c
    nrf51_sdk/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    nrf51_sdk/components/drivers_nrf/twi_master/deprecated/: twi_hw_master.c
    nrf51_sdk/components/drivers_nrf/wdt/: nrf_drv_wdt.c
  group nRF_Libraries
    nrf51_sdk/components/libraries/button/: app_button.c
    nrf51_sdk/components/libraries/util/: app_error.c nrf_assert.c
    nrf51_sdk/components/libraries/timer/: app_timer.c
    nrf51_sdk/components/libraries/trace/: app_trace.c
    nrf51_sdk/components/libraries/uart/: retarget.c
    nrf51_sdk/components/libraries/fifo/: app_fifo.c
    nrf51_sdk/components/libraries/bootloader_dfu/: dfu_app_handler.c bootloader_util.c
  group nRF_SoftDevice
    components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    nrf51_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s130_nrf51_1.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: config;components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0, Device:Startup 8.5.0
